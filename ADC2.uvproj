# Keil uVision project ADC2.uvproj, settings and files
target Target 1 (MCS-51)
  device: IS89C52 ISSI
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(40000000)
  output: ADC2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\xpt2046;.\public;.\Digitron
  group Source Group 1
    ./xpt2046/: xpt2046.c
    ./public/: public.c
    ./Digitron/: Digitron.c
    ./user/: main.c
